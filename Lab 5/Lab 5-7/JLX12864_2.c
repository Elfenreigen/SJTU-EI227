#ifndef JLX_C
#define JLX_C

#include <stdint.h>
#include <stdbool.h>
#include "inc/hw_memmap.h"
#include "inc/hw_types.h"
#include "driverlib/debug.h"
#include "driverlib/gpio.h"
#include "driverlib/pin_map.h"
#include "driverlib/sysctl.h"
#define LCD_CS_H GPIOPinWrite(GPIO_PORTB_BASE,GPIO_PIN_4,GPIO_PIN_4)
#define LCD_CS_L GPIOPinWrite(GPIO_PORTB_BASE,GPIO_PIN_4,0)
#define LCD_SCK_H GPIOPinWrite(GPIO_PORTB_BASE,GPIO_PIN_5,GPIO_PIN_5)
#define LCD_SCK_L GPIOPinWrite(GPIO_PORTB_BASE,GPIO_PIN_5,0)
#define LCD_SDA_H GPIOPinWrite(GPIO_PORTE_BASE,GPIO_PIN_4,GPIO_PIN_4)
#define LCD_SDA_L GPIOPinWrite(GPIO_PORTE_BASE,GPIO_PIN_4,0)
#define LCD_RST_H GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_0,GPIO_PIN_0)
#define LCD_RST_L GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_0,0)
#define LCD_RS_H GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_1,GPIO_PIN_1)
#define LCD_RS_L GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_1,0)

#define LCD_ROM_IN_H GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_2,GPIO_PIN_2)
#define LCD_ROM_IN_L GPIOPinWrite(GPIO_PORTK_BASE,GPIO_PIN_2,0)
#define LCD_ROM_SCK_H GPIOPinWrite(GPIO_PORTC_BASE,GPIO_PIN_5,GPIO_PIN_5)
#define LCD_ROM_SCK_L GPIOPinWrite(GPIO_PORTC_BASE,GPIO_PIN_5,0)
#define LCD_ROM_CS_H GPIOPinWrite(GPIO_PORTC_BASE,GPIO_PIN_4,GPIO_PIN_4)
#define LCD_ROM_CS_L GPIOPinWrite(GPIO_PORTC_BASE,GPIO_PIN_4,0)

#define LCD_ROM_OUT GPIOPinRead(GPIO_PORTC_BASE,GPIO_PIN_6)

#define TEST_H GPIOPinWrite(GPIO_PORTF_BASE,GPIO_PIN_1,GPIO_PIN_1)
#define TEST_L GPIOPinWrite(GPIO_PORTF_BASE,GPIO_PIN_1,0)

uint8_t bmp1[];
uint8_t jiong1[]= { //-- 文字: 囧 --
//-- 宋体 12; 此字体下对应的点阵为：宽 x 高=16x16 --
    0x00,0xFE,0x82,0x42,0xA2,0x9E,0x8A,0x82,0x86,0x8A,0xB2,0x62,0x02,0xFE,0x00,0x00,
    0x00,0x7F,0x40,0x40,0x7F,0x40,0x40,0x40,0x40,0x40,0x7F,0x40,0x40,0x7F,0x00,0x00
};
uint8_t lei1[]= { //-- 文字: 畾 --
//-- 宋体 12; 此字体下对应的点阵为：宽 x 高=16x16 --
    0x80,0x80,0x80,0xBF,0xA5,0xA5,0xA5,0x3F,0xA5,0xA5,0xA5,0xBF,0x80,0x80,0x80,0x00,
    0x7F,0x24,0x24,0x3F,0x24,0x24,0x7F,0x00,0x7F,0x24,0x24,0x3F,0x24,0x24,0x7F,0x00
};

////使能GPIO
void LCD_PORT_init(void)
{
	SysCtlPeripheralEnable(SYSCTL_PERIPH_GPIOC);
	while(!SysCtlPeripheralReady(SYSCTL_PERIPH_GPIOC));
	SysCtlPeripheralEnable(SYSCTL_PERIPH_GPIOK);
	while(!SysCtlPeripheralReady(SYSCTL_PERIPH_GPIOK));
	SysCtlPeripheralEnable(SYSCTL_PERIPH_GPIOB);
	while(!SysCtlPeripheralReady(SYSCTL_PERIPH_GPIOB));
	SysCtlPeripheralEnable(SYSCTL_PERIPH_GPIOE);
	while(!SysCtlPeripheralReady(SYSCTL_PERIPH_GPIOE));

	GPIOPinTypeGPIOOutput(GPIO_PORTK_BASE,GPIO_PIN_0 | GPIO_PIN_1 | GPIO_PIN_2);
	GPIOPinTypeGPIOOutput(GPIO_PORTC_BASE,GPIO_PIN_5 | GPIO_PIN_4);
	GPIOPinTypeGPIOOutput(GPIO_PORTB_BASE,GPIO_PIN_4 | GPIO_PIN_5);
	GPIOPinTypeGPIOOutput(GPIO_PORTE_BASE,GPIO_PIN_4);
	GPIOPinTypeGPIOInput(GPIO_PORTC_BASE,GPIO_PIN_6);

	SysCtlPeripheralEnable(SYSCTL_PERIPH_GPIOF);
	while(!SysCtlPeripheralReady(SYSCTL_PERIPH_GPIOF));
	GPIOPinTypeGPIOOutput(GPIO_PORTF_BASE,GPIO_PIN_1);
}
//延时
void LCD_delay(int n_ms)
{
    int j,k;
	TEST_L;
    for(j=0; j<n_ms; j++)
        for(k=0; k<110; k++);
	TEST_H;
}
//短延时
void LCD_delay_us(int n_us)
{
    int j,k;
    for(j=0; j<n_us; j++)
        for(k=0; k<1; k++);
}
//写指令到 LCD 模块
void transfer_command_lcd(int data1)
{
    char i;
    LCD_CS_L;
    LCD_RS_L;
    for(i=0; i<8; i++)
    {
        LCD_SCK_L;
//delay_us(10); //加少量延时
        if(data1&0x80) LCD_SDA_H;
        else LCD_SDA_L;
        LCD_SCK_H;
//delay_us(10); //加少量延时
        data1=data1<<=1;
    }
    LCD_CS_H;
}
//写数据到 LCD 模块
void transfer_data_lcd(int data1)
{
    char i;
    LCD_CS_L;
    LCD_RS_H;
    for(i=0; i<8; i++)
    {
        LCD_SCK_L;
        if(data1&0x80) LCD_SDA_H;
        else LCD_SDA_L;
        LCD_SCK_H;
        data1=data1<<=1;
    }
    LCD_CS_H;
}
//LCD 模块初始化
void initial_lcd()
{
    LCD_PORT_init();
    LCD_RST_L;
    LCD_delay(100);
    LCD_RST_H;
    LCD_delay(100);
    transfer_command_lcd(0xe2); //软复位
    LCD_delay(5);
    transfer_command_lcd(0x2c); //升压步聚 1
    LCD_delay(50);
    transfer_command_lcd(0x2e); //升压步聚 2
    LCD_delay(50);
    transfer_command_lcd(0x2f); //升压步聚 3
    LCD_delay(5);
    transfer_command_lcd(0x23); //粗调对比度，可设置范围 0x20～0x27
    transfer_command_lcd(0x81); //微调对比度
    transfer_command_lcd(0x28); //微调对比度的值，可设置范围 0x00～0x3f
    transfer_command_lcd(0xa2); //1/9 偏压比（bias）
    transfer_command_lcd(0xc8); //行扫描顺序：从上到下
    transfer_command_lcd(0xa0); //列扫描顺序：从左到右
    transfer_command_lcd(0x40); //起始行：第一行开始
    transfer_command_lcd(0xaf); //开显示
}
void lcd_address(uint32_t page,uint32_t column)
{
    column=column-0x01;
    transfer_command_lcd(0xb0+page-1); //设置页地址，每 8 行为一页，全屏共 64 行，被分成 8 页
    transfer_command_lcd(0x10+(column>>4&0x0f)); //设置列地址的高 4 位
    transfer_command_lcd(column&0x0f); //设置列地址的低 4 位
}
//全屏清屏
void clear_screen()
{
    unsigned char i,j;
    for(i=0; i<9; i++)
    {
        transfer_command_lcd(0xb0+i);
        transfer_command_lcd(0x10);
        transfer_command_lcd(0x00);
        for(j=0; j<132; j++)
        {
            transfer_data_lcd(0x00);
        }
    }
}
//显示 128x64 点阵图像
void display_128x64(uint8_t *dp)
{
    uint32_t i,j;
    for(j=0; j<8; j++)
    {
        lcd_address(j+1,1);
        for (i=0; i<128; i++)
        {
            transfer_data_lcd(*dp); //写数据到 LCD,每写完一个 8 位的数据后列地址自动加 1
            dp++;
        }
    }
}
//显示 16x16 点阵图像、汉字、生僻字或 16x16 点阵的其他图标
void display_graphic_16x16(uint8_t page,uint8_t column,uint8_t *dp)
{
    uint32_t i,j;
    for(j=0; j<2; j++)
    {
        lcd_address(page+j,column);
        for (i=0; i<16; i++)
        {
            transfer_data_lcd(*dp); //写数据到 LCD,每写完一个 8 位的数据后列地址自动加 1
            dp++;
        }
    }
}
//显示 8x16 点阵图像、ASCII, 或 8x16 点阵的自造字符、其他图标
void display_graphic_8x16(uint8_t page,uint8_t column,uint8_t *dp)
{
    uint32_t i,j;
    for(j=0; j<2; j++)
    {
        lcd_address(page+j,column);
        for (i=0; i<8; i++)
        {
            transfer_data_lcd(*dp); //写数据到 LCD,每写完一个 8 位的数据后列地址自动加 1
            dp++;
        }
    }
}
//显示 5X8 点阵图像、ASCII, 或 5x8 点阵的自造字符、其他图标
void display_graphic_5x8(uint8_t page,uint8_t column,uint8_t *dp)
{
    uint32_t i;
    lcd_address(page,column);
    for (i=0; i<6; i++)
    {
        transfer_data_lcd(*dp);
        dp++;
    }
}
//送指令到晶联讯字库 IC
void send_command_to_ROM( uint8_t datu )
{
    uint8_t i;
    for(i=0; i<8; i++ )
    {
        LCD_ROM_SCK_L;
        LCD_delay_us(10);
        if(datu&0x80)LCD_ROM_IN_H;
        else LCD_ROM_IN_L;
        datu = datu<<1;
        LCD_ROM_SCK_H;
        LCD_delay_us(10);
    }
}
//从晶联讯字库 IC 中取汉字或字符数据（1 个字节）
static uint8_t get_data_from_ROM( )
{
    uint8_t i;
    uint8_t ret_data=0;
    for(i=0; i<8; i++)
    {
        LCD_ROM_SCK_L;
//delay_us(1);
        ret_data=ret_data<<1;
        if( LCD_ROM_OUT )
            ret_data=ret_data+1;
        else
            ret_data=ret_data+0;
        LCD_ROM_SCK_H;
//delay_us(1);
    }
    return(ret_data);
}
//从指定地址读出数据写到液晶屏指定（page,column)座标中
void get_and_write_16x16(unsigned long fontaddr,uint8_t page,uint8_t column,bool inverse)
{
    uint8_t i,j,disp_data;
    LCD_ROM_CS_L;
    send_command_to_ROM(0x03);
    send_command_to_ROM((fontaddr&0xff0000)>>16); //地址的高 8 位,共 24 位
    send_command_to_ROM((fontaddr&0xff00)>>8); //地址的中 8 位,共 24 位
    send_command_to_ROM(fontaddr&0xff); //地址的低 8 位,共 24 位
    for(j=0; j<2; j++)
    {
        lcd_address(page+j,column);
        for(i=0; i<16; i++ )
        {
						if( inverse)
								disp_data=~get_data_from_ROM();
						else
								disp_data=get_data_from_ROM();
            transfer_data_lcd(disp_data); //写数据到 LCD,每写完 1 字节的数据后列地址自动加 1
        }
    }
    LCD_ROM_CS_H;
}
//从指定地址读出数据写到液晶屏指定（page,column)座标中
void get_and_write_8x16(unsigned long fontaddr,uint8_t page,uint8_t column,bool inverse)
{
    uint8_t i,j,disp_data;
    LCD_ROM_CS_L;
    send_command_to_ROM(0x03);
    send_command_to_ROM((fontaddr&0xff0000)>>16); //地址的高 8 位,共 24 位
    send_command_to_ROM((fontaddr&0xff00)>>8); //地址的中 8 位,共 24 位
    send_command_to_ROM(fontaddr&0xff); //地址的低 8 位,共 24 位
    for(j=0; j<2; j++)
    {
        lcd_address(page+j,column);
        for(i=0; i<8; i++ )
        {
            if( inverse)
								disp_data=~get_data_from_ROM();
						else
								disp_data=get_data_from_ROM();
            transfer_data_lcd(disp_data); //写数据到 LCD,每写完 1 字节的数据后列地址自动加 1
        }
    }
    LCD_ROM_CS_H;
}
//从指定地址读出数据写到液晶屏指定（page,column)座标中
void get_and_write_5x8(unsigned long fontaddr,uint8_t page,uint8_t column,bool inverse)
{
    uint8_t i,disp_data;
    LCD_ROM_CS_L;
    send_command_to_ROM(0x03);
    send_command_to_ROM((fontaddr&0xff0000)>>16); //地址的高 8 位,共 24 位
    send_command_to_ROM((fontaddr&0xff00)>>8); //地址的中 8 位,共 24 位
    send_command_to_ROM(fontaddr&0xff); //地址的低 8 位,共 24 位
    lcd_address(page,column);
    for(i=0; i<5; i++ )
    {
        if( inverse)
								disp_data=~get_data_from_ROM();
				else
								disp_data=get_data_from_ROM();
        transfer_data_lcd(disp_data); //写数据到 LCD,每写完 1 字节的数据后列地址自动加 1
    }
    LCD_ROM_CS_H;
}
//****************************************************************
unsigned long fontaddr=0;
void display_GB2312_string(uint8_t page,uint8_t column,uint8_t *text,bool inverse)
{
    uint8_t i= 0;
    while((text[i]>0x00))
    {
        if(((text[i]>=0xb0) &&(text[i]<=0xf7))&&(text[i+1]>=0xa1))
        {
//国标简体（GB2312）汉字在晶联讯字库 IC 中的地址由以下公式来计算：
//Address = ((MSB - 0xB0) * 94 + (LSB - 0xA1)+ 846)*32+ BaseAdd;BaseAdd=0
//由于担心 8 位单片机有乘法溢出问题，所以分三部取地址
            fontaddr = (text[i]- 0xb0)*94;
            fontaddr += (text[i+1]-0xa1)+846;
            fontaddr = (unsigned long)(fontaddr*32);
            get_and_write_16x16(fontaddr,page,column,inverse); //从指定地址读出数据写到液晶屏指定（page,column)座标中
            i+=2;
            column+=16;
        }
        else if(((text[i]>=0xa1) &&(text[i]<=0xa3))&&(text[i+1]>=0xa1))
        {
//国标简体（GB2312）15x16 点的字符在晶联讯字库 IC 中的地址由以下公式来计算：
//Address = ((MSB - 0xa1) * 94 + (LSB - 0xA1))*32+ BaseAdd;BaseAdd=0
//由于担心 8 位单片机有乘法溢出问题，所以分三部取地址
            fontaddr = (text[i]- 0xa1)*94;
            fontaddr += (text[i+1]-0xa1);
            fontaddr = (unsigned long)(fontaddr*32);
            get_and_write_16x16(fontaddr,page,column,inverse); //从指定地址读出数据写到液晶屏指定（page,column)座标中
            i+=2;
            column+=16;
        }
        else if((text[i]>=0x20) &&(text[i]<=0x7e))
        {
            fontaddr = (text[i]- 0x20);
            fontaddr = (unsigned long)(fontaddr*16);
            fontaddr = (unsigned long)(fontaddr+0x3cf80);
            get_and_write_8x16(fontaddr,page,column,inverse); //从指定地址读出数据写到液晶屏指定（page,column)座标中
            i+=1;
            column+=8;
        }
        else
            i++;
    }
}
void display_string_5x8(uint8_t page,uint8_t column,uint8_t *text,bool inverse)
{
    unsigned char i= 0;
    while((text[i]>0x00))
    {
        if((text[i]>=0x20) &&(text[i]<=0x7e))
        {
            fontaddr = (text[i]- 0x20);
            fontaddr = (unsigned long)(fontaddr*8);
            fontaddr = (unsigned long)(fontaddr+0x3bfc0);
            get_and_write_5x8(fontaddr,page,column,inverse); //从指定地址读出数据写到液晶屏指定（page,column)座标中
            i+=1;
            column+=6;
        }
        else
            i++;
    }
}



uint8_t bmp1[]= {
//-- 调入了一幅图像：D:\我的文档\My Pictures\12864-555.bmp --
//-- 宽度 x 高度=128x64 --
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xfc, 0x1f, 0xf8, 0x3f, 0xff, 0xff,
  0xff, 0xff, 0xf1, 0xff, 0xff, 0x87, 0xff, 0xff,
  0xff, 0xff, 0xcf, 0xff, 0xff, 0xf1, 0xff, 0xff,
  0xff, 0xff, 0x3f, 0xff, 0xdb, 0xfc, 0xff, 0xff,
  0xff, 0xfe, 0x7f, 0xff, 0x96, 0x3e, 0x3f, 0xff,
  0xff, 0xf9, 0xc1, 0xff, 0xd5, 0x6f, 0x9f, 0xff,
  0xff, 0xf3, 0xd1, 0xff, 0xfd, 0xa7, 0xcf, 0xff,
  0xff, 0xe7, 0x81, 0xff, 0xff, 0x45, 0xf7, 0xff,
  0xff, 0xdf, 0x2e, 0xfa, 0x5f, 0xed, 0xfb, 0xff,
  0xff, 0x9f, 0xef, 0xca, 0x4b, 0xfb, 0x79, 0xff,
  0xff, 0x3f, 0xdf, 0x40, 0x02, 0x7d, 0x7c, 0xff,
  0xff, 0x7f, 0xf9, 0x00, 0x00, 0x9f, 0x5e, 0x7f,
  0xfe, 0xff, 0xe8, 0x0f, 0xf0, 0x17, 0x2f, 0x3f,
  0xfc, 0xff, 0xe0, 0x7f, 0xfe, 0x07, 0xef, 0xbf,
  0xfd, 0xff, 0x81, 0xff, 0xff, 0x85, 0xcf, 0x9f,
  0xfb, 0xff, 0x83, 0xf3, 0xff, 0xc1, 0xf5, 0xdf,
  0xfb, 0xfe, 0x47, 0xf2, 0x31, 0xf0, 0x7d, 0xcf,
  0xf6, 0x3f, 0x0f, 0xf0, 0x86, 0xf8, 0x73, 0xef,
  0xf6, 0x05, 0x1f, 0xf2, 0x31, 0xfc, 0xbf, 0xe7,
  0xe4, 0x0c, 0x3f, 0xf1, 0xff, 0xfc, 0x3e, 0x77,
  0xed, 0x1e, 0x7f, 0xf1, 0xff, 0x76, 0x7b, 0x77,
  0xec, 0x98, 0x7f, 0x10, 0xff, 0x06, 0x0c, 0x73,
  0xcc, 0x1c, 0xfc, 0x30, 0xfd, 0x07, 0x1f, 0x33,
  0xdc, 0x10, 0xf0, 0x70, 0x79, 0x07, 0x0f, 0x7b,
  0xdf, 0xf0, 0xf1, 0xf0, 0x31, 0x57, 0x8e, 0x3b,
  0xdf, 0xf9, 0xe0, 0xf0, 0x85, 0x57, 0x9f, 0xfb,
  0xdf, 0xe1, 0xe0, 0x10, 0x95, 0x07, 0x86, 0x3b,
  0xdf, 0xf1, 0xe0, 0x10, 0x15, 0x07, 0x8e, 0xdb,
  0xdf, 0xf1, 0xc0, 0x10, 0x15, 0x17, 0x87, 0x39,
  0xdf, 0xe1, 0xc0, 0x10, 0x15, 0x77, 0x86, 0xf9,
  0xdf, 0xf9, 0xc0, 0x10, 0x95, 0x07, 0x9e, 0x3b,
  0xdf, 0xe1, 0xed, 0x50, 0x95, 0x07, 0x87, 0xfb,
  0xdf, 0xf1, 0xf5, 0x50, 0x85, 0x07, 0x87, 0xfb,
  0xdf, 0xb8, 0xf0, 0x54, 0xb5, 0x77, 0x9e, 0x3b,
  0xdf, 0x30, 0xf8, 0x51, 0xf9, 0x07, 0x07, 0xbb,
  0xcd, 0x7c, 0xf8, 0x14, 0x7d, 0x77, 0x3e, 0x3b,
  0xed, 0xf8, 0x78, 0x51, 0x1f, 0x07, 0x1f, 0xf3,
  0xee, 0x78, 0x7d, 0x51, 0xcf, 0xfe, 0x0c, 0x77,
  0xec, 0x7e, 0x3f, 0xf1, 0xe3, 0x3e, 0x3e, 0xf7,
  0xf6, 0xbc, 0x3f, 0xf3, 0xf8, 0x3c, 0x19, 0xe7,
  0xf7, 0x47, 0x1f, 0xf1, 0xfe, 0x38, 0xf6, 0xef,
  0xf3, 0x7e, 0x0f, 0xff, 0xfc, 0x70, 0x79, 0xef,
  0xfb, 0xff, 0xc7, 0xff, 0xfc, 0xe1, 0xff, 0xdf,
  0xf9, 0xff, 0x81, 0xff, 0xff, 0xc1, 0xef, 0xdf,
  0xfd, 0xff, 0xe0, 0xff, 0xff, 0x07, 0xf3, 0xbf,
  0xfc, 0xff, 0xe0, 0x1f, 0xfc, 0x17, 0x8f, 0x3f,
  0xfe, 0x7f, 0xf8, 0x00, 0x00, 0x1f, 0x5e, 0x7f,
  0xff, 0x3f, 0xfb, 0x00, 0x00, 0x5f, 0x3e, 0xff,
  0xff, 0xbf, 0x83, 0x48, 0x02, 0x7a, 0xbc, 0xff,
  0xff, 0xdf, 0xa3, 0xda, 0x4b, 0xf7, 0x79, 0xff,
  0xff, 0xcf, 0x83, 0xff, 0xff, 0xe6, 0xf3, 0xff,
  0xff, 0xe7, 0x00, 0xff, 0xfe, 0x8b, 0xe7, 0xff,
  0xff, 0xf9, 0x43, 0xff, 0xea, 0x67, 0xcf, 0xff,
  0xff, 0xfc, 0xd3, 0xff, 0xaa, 0x5f, 0x3f, 0xff,
  0xff, 0xfe, 0x77, 0xff, 0xca, 0xfe, 0x7f, 0xff,
  0xff, 0xff, 0x9f, 0xff, 0xdf, 0xf9, 0xff, 0xff,
  0xff, 0xff, 0xe3, 0xff, 0xff, 0xc7, 0xff, 0xff,
  0xff, 0xff, 0xf8, 0x7f, 0xff, 0x1f, 0xff, 0xff,
  0xff, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xf8, 0x0f, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
  0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
};

#endif

